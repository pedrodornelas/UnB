options:
  parameters:
    author: pedro
    generate_options: qt_gui
    id: m180108140_Exp07_AR02
    output_language: python
    title: AR02
  states: {}

blocks:
- name: f_corte
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '44100'
    value: '11000'
  states: {state: disabled}
- name: mu
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: n_bits
  id: variable_qtgui_range
  parameters:
    gui_hint: (1,1,1,2)
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '16'
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: mu+1
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_3
  id: analog_const_source_x
  parameters:
    const: 1+mu
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_2_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mu
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6366'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.6366'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_2
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {state: disabled}
- name: blocks_rms_xx_2_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: log
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: log
    type: float
  states: {}
- name: blocks_transcendental_1
  id: blocks_transcendental
  parameters:
    name: log
    type: float
  states: {}
- name: blocks_transcendental_2
  id: blocks_transcendental
  parameters:
    name: exp
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pedro/Documentos/UnB/5_Semestre/Lab_princom/180108140_Exp07/Exp_07_som.wav
    repeat: 'True'
  states: {}
- name: channels_quantizer_0
  id: channels_quantizer
  parameters:
    bits: n_bits
  states: {}
- name: channels_quantizer_0_0
  id: channels_quantizer
  parameters:
    bits: n_bits
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: f_corte
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (6,2,4,1)
    label1: RSRq Linear
    label2: RSRq Lei mu
    name: RSRq(dB) x Potência Original(dBm)
    nconnections: '2'
    size: '44100'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2,2,4,1)
    label1: Mensagem
    label2: Comprimido
    label3: Expandido
    label4: Recuperado
    name: Analisador de Espectro
    nconnections: '4'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: 100%
    label2: 99,9%
    name: Potência
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (2,1,4,1)
    label1: Mensagem
    label2: Comprimido
    label3: Expandido
    label4: Recuperado
    name: Osciloscópio
    nconnections: '4'
    size: '4096'
    srate: samp_rate
    type: float
    yunit: V
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (6,1,4,1)
    label1: RSRq_Linear
    label2: RSRq_Lei_mu
    name: Osciloscópio
    nconnections: '2'
    size: '44100'
    srate: samp_rate
    type: float
    yunit: V
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: comp quant
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: comprimido
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: potencia mensagem
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: RSRq_Linear
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: expandido
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: recuperado
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: RSRq_Lei_mu
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: comp quant
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: expandido
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: comprimido
  states: {}
- name: virtual_source_5_0_0
  id: virtual_source
  parameters:
    stream_id: recuperado
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: potencia mensagem
  states: {}
- name: virtual_source_7
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_7_0
  id: virtual_source
  parameters:
    stream_id: expandido
  states: {}
- name: virtual_source_7_1
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {state: disabled}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: RSRq_Linear
  states: {}
- name: virtual_source_8_0
  id: virtual_source
  parameters:
    stream_id: RSRq_Lei_mu
  states: {}
- name: virtual_source_9
  id: virtual_source
  parameters:
    stream_id: potencia mensagem
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_transcendental_0_0, '0']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_2, '0', blocks_float_to_complex_1, '0']
- [analog_const_source_x_3, '0', blocks_divide_xx_1, '1']
- [analog_const_source_x_3, '0', blocks_transcendental_1, '0']
- [blocks_abs_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_abs_xx_1, '0', blocks_multiply_xx_1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_transcendental_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_arg_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_divide_xx_1, '0', low_pass_filter_0, '0']
- [blocks_divide_xx_1, '0', virtual_sink_5, '0']
- [blocks_float_to_complex_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_float_to_complex_1, '0', blocks_complex_to_arg_1, '0']
- [blocks_float_to_complex_2, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_2_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', channels_quantizer_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_2, '0']
- [blocks_multiply_xx_1, '0', blocks_divide_xx_1, '0']
- [blocks_multiply_xx_1_0, '0', blocks_transcendental_2, '0']
- [blocks_multiply_xx_2, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_xx_2_0, '0', qtgui_number_sink_0, '1']
- [blocks_nlog10_ff_0, '0', blocks_sub_xx_0, '0']
- [blocks_nlog10_ff_0, '0', virtual_sink_3, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_nlog10_ff_1, '0', blocks_sub_xx_2, '0']
- [blocks_rms_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_rms_xx_1, '0', blocks_nlog10_ff_1, '0']
- [blocks_rms_xx_2, '0', blocks_multiply_xx_2, '0']
- [blocks_rms_xx_2, '0', blocks_multiply_xx_2, '1']
- [blocks_rms_xx_2_0, '0', blocks_multiply_xx_2_0, '0']
- [blocks_rms_xx_2_0, '0', blocks_multiply_xx_2_0, '1']
- [blocks_sub_xx_0, '0', virtual_sink_4, '0']
- [blocks_sub_xx_0_0, '0', blocks_rms_xx_0_0, '0']
- [blocks_sub_xx_1, '0', blocks_rms_xx_1, '0']
- [blocks_sub_xx_2, '0', virtual_sink_6, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_throttle_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_1_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_transcendental_0, '0', blocks_divide_xx_0, '0']
- [blocks_transcendental_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_transcendental_1, '0', blocks_multiply_xx_1_0, '1']
- [blocks_transcendental_2, '0', blocks_add_const_vxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [channels_quantizer_0, '0', virtual_sink_1, '0']
- [channels_quantizer_0_0, '0', blocks_sub_xx_0_0, '1']
- [low_pass_filter_0, '0', virtual_sink_5_0, '0']
- [low_pass_filter_1, '0', blocks_rms_xx_2_0, '0']
- [virtual_source_0, '0', blocks_abs_xx_0, '0']
- [virtual_source_1, '0', blocks_float_to_complex_0, '1']
- [virtual_source_2, '0', blocks_rms_xx_0, '0']
- [virtual_source_2, '0', blocks_sub_xx_0_0, '0']
- [virtual_source_2, '0', channels_quantizer_0_0, '0']
- [virtual_source_3, '0', blocks_abs_xx_1, '0']
- [virtual_source_3, '0', blocks_float_to_complex_1, '1']
- [virtual_source_4, '0', blocks_sub_xx_1, '0']
- [virtual_source_5, '0', blocks_sub_xx_1, '1']
- [virtual_source_5_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_5_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_5_0_0, '0', audio_sink_0, '0']
- [virtual_source_5_0_0, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_5_0_0, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_6, '0', blocks_sub_xx_2, '1']
- [virtual_source_7, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_7, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_7_0, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_7_0, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_7_1, '0', blocks_rms_xx_2, '0']
- [virtual_source_7_1, '0', low_pass_filter_1, '0']
- [virtual_source_8, '0', blocks_float_to_complex_2, '1']
- [virtual_source_8, '0', blocks_throttle_1, '0']
- [virtual_source_8_0, '0', blocks_float_to_complex_2_0, '1']
- [virtual_source_8_0, '0', blocks_throttle_1_0, '0']
- [virtual_source_9, '0', blocks_float_to_complex_2, '0']
- [virtual_source_9, '0', blocks_float_to_complex_2_0, '0']

metadata:
  file_format: 1
